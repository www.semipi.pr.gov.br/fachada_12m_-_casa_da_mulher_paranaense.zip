Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0, QuantityTakeOffAddOnView], RevitIdentifiers [ContentGUID: 6889124e-a045-4518-ae45-402d1974aa4e, VersionGUID: 6649f917-6bd9-4f10-b3c7-2c8b196b592c, NumberOfSaves: 83], CoordinateReference [CoordinateBase: Origem interna, ProjectSite: Terreno padrão]
File name: FACHADA 12M.ifc
Time: 2025-05-29T18:02:58-03:00
Written by: ODA SDAI 24.6
Made in: Autodesk Revit 24.3.10.22 (PTB) - IFC 24.3.10.22

# IfcProject, 0001
LongName: ARQUITETÔNICO; Phase: Status do projeto

# IfcSite, Default
RefLatitude: 42, 24, 53, 508911; RefLongitude: -71, -15, -29, -58837; RefElevation: 0 cm
Outros - Categoria: Informações do projeto; Data de emissão do projeto: Data de emissão; Endereço do projeto: ççççççççççç; Nome do cliente: Proprietário; Nome do projeto: ARQUITETÔNICO; Número do projeto: 0001; Status do projeto: Status do projeto

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1
Outros - Categoria: Informações do projeto; Data de emissão do projeto: Data de emissão; Endereço do projeto: ççççççççççç; Nome do cliente: Proprietário; Nome do projeto: ARQUITETÔNICO; Número do projeto: 0001; Status do projeto: Status do projeto

# IfcBuildingStorey: Nível:Cabeça de 8 mm (3)
Outros - Categoria: Níveis; Família: Nível; Família e tipo: Nível: Cabeça de 8 mm; ID de tipo: 305; Tipo: Cabeça de 8 mm
Cotas - Cálculo da altura: 0 cm
Dados de identidade - Andar da construção: yes; Estrutural: no
Outros(Tipo) - Categoria: Níveis; Nome da família: Nível
Restrições(Tipo) - Base da elevação: Ponto base do projeto
Gráficos(Tipo) - Cor: 0; Espessura da linha: 1; Padrão de linha: Centro (1); Símbolo: M_Cabeça do nível - Círculo; Símbolo no final 1 padrão: no; Símbolo no final 2 padrão: yes
Dados de identidade(Tipo) - Nome do tipo: Cabeça de 8 mm
Name | LongName = Nome | Elevation (cm) = Elevação (cm)
N.A 0.00 | N.A 0.00 | 0
N.O 4.50 | N.O 4.50 | 450
N.O 5.50 | N.O 5.50 | 550

# IfcBuildingElementProxy: Modelos genéricos : (400)TOTEM : (400)TOTEM
In: N.A 0.00
Type - Material: MATERIAL ROSA PAINEL, MATERIAL VERDE PAINEL, PAINELPINTURA BRANCA
Type - Outros - Categoria: Modelos genéricos; N BARRAS HORIZ.: 15; Nome da família: (400)TOTEM
Type - Restrições - Elevação padrão: 0 cm
Type - Cotas - ALTURA: 180 cm; LARGURA: 80 cm; MEIA LARGURA: 40 cm
Type - Dados de identidade - Nome do tipo: (400)TOTEM
Type - Materiais e acabamentos - LETRA CMP: MATERIAL ROSA PAINEL; LETRA MUNICIPIO: LOGO PARANÁ AZUL ESC.; LETRA ZILDA: MATERIAL VERDE PAINEL; MATERIAL GRADE: PAINELPINTURA BRANCA; MATERIAL LOGO CASA: MATERIAL VERDE PAINEL; MATERIAL LOGO MULHER: MATERIAL ROSA PAINEL
Pset_BuildingElementProxyCommon - Reference: (400)TOTEM:(400)TOTEM; sets with these values: 2
Outros - Família: (400)TOTEM; Família e tipo: (400)TOTEM: (400)TOTEM; ID de tipo: 4983121; Tipo: (400)TOTEM
Restrições - Move com elementos próximos: no; Nível: N.A 0.00; Deslocamento do hospedeiro: -3.78535 cm; Elevação do nível: -3.78535 cm; Hospedeiro: Nível : N.A 0.00
Cotas - Área: 4.53422 m2; Volume: 0.533308 m3
Fases - Fase criada: Construção nova

# IfcBuildingElementProxy: Modelos genéricos : (reduzido 450) PAINEL CMP (CURVO E LOGOS) : (reduzido 450) PAINEL CMP (CURVO E LOGOS)
In: N.A 0.00
Type - Material: PAINELPINTURA BRANCA, LOGO PARANÁ AZUL ESC., MATERIAL ROSA PAINEL, MATERIAL VERDE PAINEL, LOGO PARANÁ AZUL, LOGO PARANÁ VERDE, LOGO PARANÁ BRANCO, LOGO PARANÁ VERMELHO, LOGO PARANÁ PRETO, LOGO PARANÁ AMARELO
Type - Outros - Categoria: Modelos genéricos; N BARRAS HORIZ.: 15; Nome da família: (reduzido 450) PAINEL CMP (CURVO E LOGOS)
Type - Restrições - Elevação padrão: 0 cm
Type - Cotas - ALTURA: 180 cm; LARGURA: 80 cm; MEIA LARGURA: 40 cm
Type - Dados de identidade - Nome do tipo: (reduzido 450) PAINEL CMP (CURVO E LOGOS)
Type - Materiais e acabamentos - LETRA CMP: MATERIAL ROSA PAINEL; LETRA MUNICIPIO: LOGO PARANÁ AZUL ESC.; LETRA ZILDA: MATERIAL VERDE PAINEL; MATERIAL GRADE: PAINELPINTURA BRANCA; MATERIAL LOGO CASA: MATERIAL VERDE PAINEL; MATERIAL LOGO MULHER: MATERIAL ROSA PAINEL
Pset_BuildingElementProxyCommon - Reference: (reduzido 450) PAINEL CMP (CURVO E LOGOS):(reduzido 450) PAINEL CMP (CURVO E LOGOS); sets with these values: 2
Outros - Família: (reduzido 450) PAINEL CMP (CURVO E LOGOS); Família e tipo: (reduzido 450) PAINEL CMP (CURVO E LOGOS): (reduzido 450) PAINEL CMP (CURVO E LOGOS); ID de tipo: 4421041; Tipo: (reduzido 450) PAINEL CMP (CURVO E LOGOS)
Restrições - Move com elementos próximos: no; Nível: N.A 0.00; Deslocamento do hospedeiro: 86.2147 cm; Elevação do nível: 86.2147 cm; Hospedeiro: Nível : N.A 0.00
Cotas - Área: 28.8827 m2; Volume: 0.364264 m3
Fases - Fase criada: Construção nova

# IfcBuildingElementProxy: Modelos genéricos : (reduzido) PAINEL CMP (ARAUCÁRIA) : (reduzido) PAINEL CMP (ARAUCÁRIA)
In: N.A 0.00
Type - Material: MATERIAL ROSA PAINEL, MATERIAL LARANJA PAINEL, MATERIAL VERDE PAINEL
Type - Outros - Categoria: Modelos genéricos; N BARRAS HORIZ.: 15; Nome da família: (reduzido) PAINEL CMP (ARAUCÁRIA)
Type - Restrições - Elevação padrão: 0 cm
Type - Cotas - ALTURA: 180 cm; LARGURA: 80 cm; MEIA LARGURA: 40 cm
Type - Dados de identidade - Nome do tipo: (reduzido) PAINEL CMP (ARAUCÁRIA)
Type - Materiais e acabamentos - MATERIAL GRADE: MATERIAL ROSA PAINEL; MATERIAL PINHEIRO: MATERIAL VERDE PAINEL; MATERIAL PINHEIRO 2: MATERIAL LARANJA PAINEL
Pset_BuildingElementProxyCommon - Reference: (reduzido) PAINEL CMP (ARAUCÁRIA):(reduzido) PAINEL CMP (ARAUCÁRIA); sets with these values: 2
Outros - Família: (reduzido) PAINEL CMP (ARAUCÁRIA); Família e tipo: (reduzido) PAINEL CMP (ARAUCÁRIA): (reduzido) PAINEL CMP (ARAUCÁRIA); ID de tipo: 4525588; Tipo: (reduzido) PAINEL CMP (ARAUCÁRIA)
Restrições - Deslocamento do hospedeiro: 0 cm; Elevação do nível: 0 cm; Move com elementos próximos: no; Nível: N.A 0.00; Hospedeiro: Nível : N.A 0.00
Cotas - Área: 16.1507 m2; Volume: 0.201943 m3
Fases - Fase criada: Construção nova

# IfcBuildingElementProxy: Modelos genéricos : (reduzido)PAINEL VAZADO - 90CM : (reduzido)PAINEL VAZADO - 90CM
In: N.A 0.00
Type - Material: PAINELPINTURA BRANCA, VIDRO LARANJA CMP
Type - Outros - Categoria: Modelos genéricos; Nome da família: (reduzido)PAINEL VAZADO - 90CM
Type - Restrições - Elevação padrão: 0 cm
Type - Dados de identidade - Nome do tipo: (reduzido)PAINEL VAZADO - 90CM
Pset_BuildingElementProxyCommon - Reference: (reduzido)PAINEL VAZADO - 90CM:(reduzido)PAINEL VAZADO - 90CM; sets with these values: 2
Outros - Família: (reduzido)PAINEL VAZADO - 90CM; Família e tipo: (reduzido)PAINEL VAZADO - 90CM: (reduzido)PAINEL VAZADO - 90CM; ID de tipo: 4456027; Tipo: (reduzido)PAINEL VAZADO - 90CM
Restrições - Deslocamento do hospedeiro: 0 cm; Elevação do nível: 0 cm; Hospedeiro: Nível : N.A 0.00; Move com elementos próximos: no; Nível: N.A 0.00
Cotas - Área: 14.1318 m2; Volume: 0.369019 m3
Fases - Fase criada: Construção nova

# IfcBuildingElementProxy: Modelos genéricos : Modelos genéricos 4 : Modelos genéricos 4
In: N.A 0.00
Type - Material: <Unnamed>
Type - Outros - Categoria: Modelos genéricos; Nome da família: Modelos genéricos 4
Type - Dados de identidade - Nome do tipo: Modelos genéricos 4
Pset_BuildingElementProxyCommon - Reference: Modelos genéricos 4:Modelos genéricos 4; sets with these values: 2
Outros - Família: Modelos genéricos 4; Família e tipo: Modelos genéricos 4: Modelos genéricos 4; ID de tipo: 4379589; Tipo: Modelos genéricos 4
Restrições - Move com elementos próximos: no
Cotas - Área: 292.95 m2; Volume: 1171.8 m3
Fases - Fase criada: Construção nova

# IfcBuildingElementProxy: Modelos genéricos : TOTEM RETANGULAR : TOTEM RETANGULAR
In: N.A 0.00
Type - Material: PAINELPINTURA BRANCA, MATERIAL ROSA PAINEL, MATERIAL VERDE PAINEL
Type - Outros - Categoria: Modelos genéricos; N BARRAS HORIZ.: 15; Nome da família: TOTEM RETANGULAR
Type - Restrições - Elevação padrão: 0 cm
Type - Cotas - ALTURA: 180 cm; LARGURA: 80 cm; MEIA LARGURA: 40 cm
Type - Dados de identidade - Nome do tipo: TOTEM RETANGULAR
Type - Materiais e acabamentos - LETRA CMP: MATERIAL ROSA PAINEL; LETRA MUNICIPIO: LOGO PARANÁ AZUL ESC.; LETRA ZILDA: MATERIAL VERDE PAINEL; MATERIAL GRADE: PAINELPINTURA BRANCA; MATERIAL LOGO CASA: MATERIAL VERDE PAINEL; MATERIAL LOGO MULHER: MATERIAL ROSA PAINEL
Pset_BuildingElementProxyCommon - Reference: TOTEM RETANGULAR:TOTEM RETANGULAR; sets with these values: 2
Outros - Família: TOTEM RETANGULAR; Família e tipo: TOTEM RETANGULAR: TOTEM RETANGULAR; ID de tipo: 4107749; Tipo: TOTEM RETANGULAR
Restrições - Move com elementos próximos: no; Nível: N.A 0.00; Deslocamento do hospedeiro: -3.79 cm; Elevação do nível: -3.79 cm; Hospedeiro: Nível : N.A 0.00
Cotas - Área: 4.17514 m2; Volume: 0.378478 m3
Fases - Fase criada: Construção nova
